# IAR project FT_TSCP.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8AL3L66 STM8AL3L66
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8AL31_L_MD
  ICCSTM8.CCIncludePath2: ; STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: FT_TSCP.srec
  ILINK.IlinkOutputFile: FT_TSCP.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: battery_voltage.c battery_voltage.h bsp.c bsp.h bsp_adc.c bsp_adc.h bsp_clk_config.c bsp_clk_config.h bsp_eeprom.c bsp_eeprom.h bsp_encoder.c bsp_encoder.h bsp_itc_config.c bsp_itc_config.h bsp_led.c bsp_led.h bsp_pwm_timer.c bsp_pwm_timer.h bsp_rf_com.c bsp_rf_com.h bsp_rfm22reg.h bsp_spi.c bsp_spi.h bsp_timing_delay.c bsp_timing_delay.h communication_handler.c communication_handler.h ft_remote_types.h main.c speed_controller.c speed_controller.h stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h thread_handler.c thread_handler.h
  group SPL
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
